options:
  parameters:
    generate_options: qt_gui
    id: stream
    output_language: python
    title: stream
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_2, '0', virtual_sink_0, '0']

metadata:
  file_format: 1
