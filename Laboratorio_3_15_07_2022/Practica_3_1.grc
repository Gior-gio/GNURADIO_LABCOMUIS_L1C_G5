options:
  parameters:
    author: 'Juan_Rondòn y Jorge Angarita '
    category: '[ModulosJJ]'
    generate_options: qt_gui
    id: Practica_3_1
    output_language: python
    title: Pràctica_3_1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: Signal1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: Signal2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}

connections:
- [Signal1, '0', blocks_selector_0, '0']
- [Signal2, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
