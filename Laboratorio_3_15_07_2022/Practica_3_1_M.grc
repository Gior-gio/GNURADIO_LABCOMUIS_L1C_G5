options:
  parameters:
    author: Juan Rondon y Jorge Angarita
    generate_options: qt_gui
    id: Practica_3_1_M
    output_language: python
    title: Practica_3_1_M
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: Practica_3_1_ParteEnteraL1C_0
  id: Practica_3_1_ParteEnteraL1C
  parameters:
    Param1: 'True'
    Param2: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '512'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Practica_3_1_ParteEnteraL1C_0, '0', qtgui_time_sink_x_0, '0']
- [Practica_3_1_ParteEnteraL1C_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', Practica_3_1_ParteEnteraL1C_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
