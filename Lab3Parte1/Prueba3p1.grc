options:
  parameters:
    author: JKRJEA
    generate_options: qt_gui
    id: Prueba3P1
    output_language: python
    title: Prueba3P1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Lab3L1C_ParteEntera3L1C_0
  id: Lab3L1C_ParteEntera3L1C
  parameters:
    Param1: 'False'
    Param2: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Lab3L1C_ParteEntera3L1C_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Lab3L1C_ParteEntera3L1C_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
